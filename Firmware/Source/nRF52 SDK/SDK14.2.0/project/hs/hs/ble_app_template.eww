<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\pca10040e\s112\iar\ble_app_template_pca10040e_s112.ewp</path>
    </project>
    <batchBuild />
</workspace>
